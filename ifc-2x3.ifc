Properties of the parts of a building model (IFC2X3)

# File
Description: Stecksockel für RTBSB-001.xxx, vorverdrahtet, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MN990003, Stecksockel für RTBSB-001.xxx, vorverdrahtet
In: Raum
Description: Stecksockel komplett vorverdrahtet, kann mit Raumthermostaten RTBSB-001.086 oder RTBSB-001.096 komplettiert werden; Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MN990003; ModelLabel: JZ-19; GlobalTradeItemNumber: 4050528051684; ProductURL: https://alre.de/produkt_MN990003
Pset_Specification - NominalLength: 0.0773 m; NominalWidth: 0.0726 m; NominalDepth: 0.019 m; NetWeight: 0.059
Pset_ALRE_ETIM_Properties - Ausführung: sonstige; Länge: 72.6; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MN990003.pdf
